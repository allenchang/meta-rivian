IMAGE_INSTALL += "rbutton"
